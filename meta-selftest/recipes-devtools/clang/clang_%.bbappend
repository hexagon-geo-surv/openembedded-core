# Enable CLANG testsuite
CLANG_ENABLE_TESTSUITE = "1"
